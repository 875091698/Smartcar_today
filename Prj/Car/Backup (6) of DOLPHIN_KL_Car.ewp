# IAR project Backup (6) of DOLPHIN_KL_Car.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL26Z256xxx4 Freescale MKL26Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; MKL26Z4; ARM_MATH_CM0PLUS
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\KL_Car; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\SD_CARD
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DOLPHIN_KL_Car.hex
  ILINK.IlinkOutputFile: DOLPHIN_KL_Car.out
  ILINK.IlinkIcfFile: config files\256KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: main.c MKL_it.c
  group Board
    ../../Board/Src/: 5110.c ASCII.c bluetooth.c camera.c dolphin.c key.c key_event.c LCD.c LCD_CH.c LCD_ST7735R.c LCD_ST7735S.c LED.C MKL_conf.c MMA7455.c NRF24L0.c NRF24L0_MSG.c OV7725_Eagle.c pid.c pwm.c SCCB.c TSL1401.c UI_VAR.c
  group Chip
    ../../Chip/Src/: misc.c MKL_adc.c MKL_dac.c MKL_dma.c MKL_flash.c MKL_gpio.c MKL_i2c.c MKL_lptmr.c MKL_mcg.c MKL_PIT.c MKL_port.c MKL_spi.c MKL_SysTick.c MKL_TPM.c MKL_uart.c MKL_wdog.c
    ../../Chip/Src/KL_Car/: startup_MKL.s system_MKL.c vectors.c
  group includes
    ../../Chip/Inc/: common.h
    ../../App/Inc/: include.h MKL_it.h
    ../../Board/Inc/: MKL_conf.h
  group LIB/CMSIS
    ../../Lib/CMSIS/: iar_cortexM0plusl_math.a
